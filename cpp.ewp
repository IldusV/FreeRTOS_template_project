# IAR project cpp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_STM320518_EVAL; STM32F0XX; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: Libraries\STM32F0xx_StdPeriph_Driver\inc; Libraries\CMSIS\Device\ST\STM32F0xx\Include; Libraries\CMSIS\Include; Eval-Board; $PROJ_DIR$; Extra; ..\..\Source\include; ..\..\Source\portable\IAR\ARM_CM0; ..\Common\include; RTOS\include; RTOS\portable\IAR\ARM_CM0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: cppxxxx.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32f0xx_flash.icf
  ILINK.IlinkAdditionalLibs: Debug\Exe\RTOSDemo.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: RTOS\portable\IAR\ARM_CM0; RTOS; RTOS\include; $PROJ_DIR$; Extra; Eval-Board; Libraries\STM32F0xx_StdPeriph_Driver\inc; Libraries\CMSIS\Include; Libraries\CMSIS\Device\ST\STM32F0xx\Include
  group (top)
    ./: main-blinky.cpp main-full.cpp main.cpp ParTest.c startup_stm32f0xx.s try.cpp
    Eval-Board/: stm320518_eval.c
  group Libraries/CMSIS
    Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Libraries/StdPeriph_Driver
    Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c
