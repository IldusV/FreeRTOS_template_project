# IAR project RTOSDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_STM320518_EVAL; STM32F0XX; USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: Libraries\STM32F0xx_StdPeriph_Driver\inc; Libraries\CMSIS\Device\ST\STM32F0xx\Include; Libraries\CMSIS\Include; Eval-Board; $PROJ_DIR$; RTOS\include; RTOS\portable\IAR\ARM_CM0; Extra; RTOS\portable\MemMang
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: RTOSDemo.bin
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkIcfFile: stm32f0xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: FreeRTOSConfig.h RegTest.s
  group FreeRTOS
    RTOS/: list.c queue.c tasks.c timers.c
  group FreeRTOS/Portable
    RTOS/portable/MemMang/: heap_2.c
    RTOS/portable/IAR/ARM_CM0/: port.c portasm.s portmacro.h
  group Standard-Demo-Tasks
    Extra/: blocktim.c countsem.c dynamic.c recmutex.c
